** sch_path: 1_And_Gate/and.sch
**.subckt and B A VP VN Y
*.ipin B
*.ipin A
*.iopin VP
*.iopin VN
*.opin Y
X2 net1 Y VP VN inverter
X3 A net1 VP VN B nand
**.ends
.end
